options:
  parameters:
    author: Ashley Beard
    description: 'Generates signal with five randomized-frequency signals and a Gaussian noise source. Seperates frequencies into bins and estimates power of each to locate signals in bandwidth. '
    generate_options: no_gui
    id: power_estimation
    output_language: python
    realtime_scheduling: '1'
    title: Power Estimation Flowgraph
  states: {}

blocks:
- name: freq_0
  id: variable
  parameters:
    value: random.uniform(2.412e9, 2.462e9)
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: random.uniform(2.412e9, 2.462e9)
  states: {}
- name: freq_2
  id: variable
  parameters:
    value: random.uniform(2.412e9, 2.462e9)
  states: {}
- name: freq_3
  id: variable
  parameters:
    value: random.uniform(2.412e9, 2.462e9)
  states: {}
- name: freq_4
  id: variable
  parameters:
    value: random.uniform(2.412e9, 2.462e9)
  states: {}
- name: function_probe_1
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_0_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 166e6
  states: {}
- name: source_amp
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: variable_function_probe_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_0_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_0_0_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: source_amp
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: source_amp
    freq: freq_4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: source_amp
    freq: freq_3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: source_amp
    freq: freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: source_amp
    freq: freq_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_3_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_3_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_3_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '18'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '18'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '18'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(18)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '5']
- [analog_sig_source_x_1, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_1, '4']
- [analog_sig_source_x_1_0_0, '0', blocks_add_xx_1, '3']
- [analog_sig_source_x_1_0_0_0, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_1_0_0_0_0, '0', blocks_add_xx_1, '2']
- [blocks_add_xx_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_probe_signal_x_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_probe_signal_x_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0_0, '0', blocks_probe_signal_x_0_0, '0']
- [blocks_complex_to_mag_squared_1_0_0_0, '0', blocks_probe_signal_x_0_0_1_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0_0_0_0, '0', blocks_probe_signal_x_0_0_1_0_0, '0']
- [blocks_complex_to_mag_squared_1_0_0_0_0_0, '0', blocks_probe_signal_x_0_0_1_0, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_2_0, '0', blocks_probe_signal_x_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_2_0_0, '0', blocks_probe_signal_x_0_0_1, '0']
- [blocks_complex_to_mag_squared_2_0_0_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_complex_to_mag_squared_3, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_3_0, '0', blocks_probe_signal_x_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_3_0_0, '0', blocks_probe_signal_x_0_0_1_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_3_0_0_0, '0', blocks_probe_signal_x_0_0_1_0_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_complex_to_mag_squared_1, '0']
- [blocks_vector_to_streams_0, '10', blocks_complex_to_mag_squared_1_0_0, '0']
- [blocks_vector_to_streams_0, '11', blocks_complex_to_mag_squared_2_0_0, '0']
- [blocks_vector_to_streams_0, '12', blocks_complex_to_mag_squared_3_0_0, '0']
- [blocks_vector_to_streams_0, '13', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '14', blocks_complex_to_mag_squared_1_0_0_0, '0']
- [blocks_vector_to_streams_0, '15', blocks_complex_to_mag_squared_3_0_0_0, '0']
- [blocks_vector_to_streams_0, '16', blocks_complex_to_mag_squared_1_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '17', blocks_complex_to_mag_squared_1_0_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_complex_to_mag_squared_2, '0']
- [blocks_vector_to_streams_0, '3', blocks_complex_to_mag_squared_3, '0']
- [blocks_vector_to_streams_0, '4', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_vector_to_streams_0, '5', blocks_complex_to_mag_squared_2_0_0_0, '0']
- [blocks_vector_to_streams_0, '6', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_vector_to_streams_0, '7', blocks_complex_to_mag_squared_2_0, '0']
- [blocks_vector_to_streams_0, '8', blocks_complex_to_mag_squared_3_0, '0']
- [blocks_vector_to_streams_0, '9', blocks_complex_to_mag_squared_0_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
